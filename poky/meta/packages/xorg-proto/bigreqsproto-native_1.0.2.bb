require bigreqsproto_${PV}.bb

inherit native
