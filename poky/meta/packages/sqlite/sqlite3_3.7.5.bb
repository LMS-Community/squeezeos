require sqlite3.inc

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3070500.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3070500"
PR = "r0"