require libautoxs-header-perl_${PV}.bb
inherit native

PR = "r2"

