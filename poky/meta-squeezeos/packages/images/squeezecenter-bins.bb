DESCRIPTION = "SqueezeCenter - Transcoders and other binaries"

IMAGE_INSTALL = "faad2"

