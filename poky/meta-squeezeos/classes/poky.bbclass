MIRRORS_append () {
ftp://.*/.*    http://downloads.slimdevices.com/poky-cache/
http://.*/.*   http://downloads.slimdevices.com/poky-cache/
https://.*/.*   http://downloads.slimdevices.com/poky-cache/
}
