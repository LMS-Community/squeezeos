require xcmiscproto_${PV}.bb

inherit native
